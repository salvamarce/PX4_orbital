## src/drivers/transponder/uavionix/Kconfig
```kconfig
menuconfig DRIVERS_TRANSPONDER_UAVIONIX
	bool "uavionix"
	default n
	---help---
		Enable support for uAvionix
```
